## sdkconfig.defaults
```kconfig
# Default SDK config for hatch_clock project
CONFIG_ESP_MAIN_TASK_STACK_SIZE=8192
CONFIG_FREERTOS_HZ=1000
```
